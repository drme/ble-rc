# IAR project ble-rc.ewp, settings and files
configuration CC2541 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; xRC_PWM; xRC_BUG; xDS18B20_V1; xRC_CAR; MINI_Z_BLDC; xRC_CAR; xMINI_Z; xDNANO
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt; ..\..\Profiles\HIDDev; ..\..\Profiles\ScanParam; ..\Source
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; xRC_CAR; RC_BUG; xRC_LARGE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\RadioControll-Fancy; ..\..\Profiles\DevInfo; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\OAD; ..\..\Profiles\ScanParam; ..\..\ble-rc-fancy\Source
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 2
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2541-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; xRC_CAR; RC_BUG; xRC_LARGE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; ..\..\Profiles\RadioControll-Fancy; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\ScanParam; ..\..\ble-rc-fancy\Source
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration MiniZ-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; MINI_Z
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\OAD; ..\..\Profiles\ScanParam; ..\..\ble-rc-fancy\Source
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 2
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration MiniZ-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; MINI_Z
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration dNano (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; FIRMWARE_TYPE_DNANO
configuration dNano-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; FIRMWARE_TYPE_DNANO
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\OAD; ..\..\Profiles\ScanParam; ..\Source
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 2
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration dNano-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; FIRMWARE_TYPE_DNANO
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\ScanParam; ..\Source
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration MiniZ-BLDC-Hack (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; RC_BUG
configuration Mini-Z-BLDC (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; xPOWER_SAVING; MINI_Z_BLDC; RC_TYPE=1
configuration MiniZ-BLDC-ImgA (8051)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; MINI_Z_BLDC; RC_TYPE=1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\OAD; ..\..\Profiles\ScanParam; Source
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 2
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration MiniZ-BLDC-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; MINI_Z_BLDC; RC_TYPE=1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; ..\..\Profiles\RadioControll-Fancy; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\ScanParam; Source
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration Simple (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; FIRMWARE_TYPE_SIMPLE
configuration Simple-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; FIRMWARE_TYPE_SIMPLE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\OAD; ..\..\Profiles\ScanParam
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 2
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration Simple-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; FIRMWARE_TYPE_SIMPLE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; ..\..\Profiles\RadioControll-Fancy; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\ScanParam; ..\Source
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration EscServo (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; FIRMWARE_TYPE_ESCSERVO
configuration EscServo-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; FIRMWARE_TYPE_ESCSERVO
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\RadioControll-Fancy; ..\..\Profiles\DevInfo; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\OAD; ..\..\Profiles\ScanParam; ..\Source
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 2
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration EscServo-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; FIRMWARE_TYPE_ESCSERVO
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration EscServoLarge (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; FIRMWARE_TYPE_ESCSERVO2
configuration EscServoLarge-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 2
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration EscServoLarge-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
  group APP
    ../Source/: car_control.h car_control_base.c car_control_dnano.c car_control_m6.c car_control_mini_z.c car_control_mini_z_bldc.c car_control_rc.c car_control_rc_large.c car_control_simple.c car_control_tank.c hal_temp.h hal_temp_internal.c
  group APP/Base
    ../Source/: blercprofile.c blercprofile.h racecar.c racecar.h startup.c startup_osal.c
  group APP/Drivers
    ../Source/: hal_acc.c hal_ds18b20.c hal_ds18b20.h hal_ina220.c hal_ina220.h hal_ina226.c hal_ina226.h
  group APP/Utils
    ../Source/: accelerometerservice.c accelerometerservice.h devinfoservice-st.c dl_util.c dl_util.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2541ST/: hal_acc.h hal_i2c.c hal_i2c.h hal_sensor.c hal_sensor.h
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group NPI
    ../../common/npi/npi_np/: npi.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/: battservice.c battservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/HIDDev/: hid_uuid.h hiddev.c hiddev.h
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
  group PROFILES/LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
